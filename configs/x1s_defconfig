## configs/x1s_defconfig
```kconfig
CONFIG_CROSS_COMPILE="aarch64-linux-gnu-"
CONFIG_EXYNOS_990=y
CONFIG_SAMSUNG_X1S=y
CONFIG_CUSTBIN_PATH="blob/customBinaries/EDK2FV"
```
